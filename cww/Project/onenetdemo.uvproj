# Keil uVision project onenetdemo.uvproj, settings and files
target OneNET_Demo_ESP8266_EDP_Led (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: onenetdemo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\Driver;..\object;..\Project;..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\CMSIS\startup\arm;..\EDP;..\Network;..\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group USER
    ../User/: main.c stm32f10x_it.c
  group LIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group DRIVE
    ../Driver/: usart1.c usart2.c led.c sht20.c hal_i2c.c irenti.c jidianqi1.c duoji.c
  group EDP
    ../EDP/: cJSON.c EdpKit.c
  group Network
    ../Network/: esp8266.c
  group UTILS
    ../Utils/: utils.c
